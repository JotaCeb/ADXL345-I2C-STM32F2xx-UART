# Keil uVision project ADXL345-I2C-STM32F2xx-UART.uvprojx, settings and files
target ADXL345-I2C-STM32F2xx-UART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ADXL345-I2C-STM32F2xx-UART.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ..\Drivers\ADXL345\Includes;../Inc;..\Drivers\STM32F2xx_HAL_Driver\Inc;..\Drivers\STM32F2xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F2xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_flash.c stm32f2xx_hal.c stm32f2xx_hal_tim.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma.c stm32f2xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User
    ../Src/: stm32f2xx_hal_msp.c main.c stm32f2xx_it.c
  group ADXL345
    ../Drivers/ADXL345/Source/: ADXL345_Driver_English.c
software components: CMSIS:CORE 4.1.0
